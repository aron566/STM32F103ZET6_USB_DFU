# IAR project STM32F103ZET6_USB_DFU.ewp, settings and files
configuration STM32F103ZET6_USB_DFU (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\App\Component; ..\App\Main; ..\Utilities; ..\Middlewares\FAL\inc; ..\Middlewares\FAL\port; ..\Middlewares\SFUD\inc; ..\Middlewares\SFUD\port
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103ZET6_USB_DFU.hex
  ILINK.IlinkOutputFile: STM32F103ZET6_USB_DFU.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Component
    ../App/Component/: Flash_Port.c Timer_Port.c UART_Port.c Update_Port.c
  group Application/User/Core
    ../Core/Src/: dma.c gpio.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c
  group Application/User/Main
    ../App/Main/: User_Main.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_dfu_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c
  group Middlewares/FAL/port
    ../Middlewares/FAL/port/: fal_cfg.h fal_flash_sfud_port.c fal_flash_stm32f1_port.c
  group Middlewares/FAL/src
    ../Middlewares/FAL/src/: fal.c fal_flash.c fal_partition.c
  group Middlewares/SFUD/port
    ../Middlewares/SFUD/inc/: sfud_cfg.h sfud_flash_def.h
    ../Middlewares/SFUD/port/: sfud_port.c
  group Middlewares/SFUD/src
    ../Middlewares/SFUD/src/: sfud.c sfud_sfdp.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Utilities
    ../Utilities/: CircularQueue.c utilities.c utilities_crc.c Utilities_Multi_Button.c Utilities_Multi_Timer.c YModem.c
